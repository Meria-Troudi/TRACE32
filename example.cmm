PRINT "FLASHING DONE"